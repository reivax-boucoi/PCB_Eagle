File: solar/main.brd (EAGLE design)
At the start: 73.7 x 66 mm, 28 parts

Commit message: sdfsdfsff
Routing:
- net GND: track 76.2 -> 76.9 mm
