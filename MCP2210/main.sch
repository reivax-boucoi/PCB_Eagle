File: MCP2210/main.sch (EAGLE design)
At the start: 0 parts

Commit message: added usb conn
Parts:
- added J1: USB_A_SMT_MALE, SparkFun-Connectors:USB_A_SMT_MALE
